# Keil uVision project STM32-DEMO.uvprojx, settings and files
target USART1-DEMO (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-DEMO +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\FWlib\inc;..\USER;..\HARDWARE\stm32_adc;..\HARDWARE\stm32_dac;..\HARDWARE\stm32_tim2;..\HARDWARE\stm32_led
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c usart1.c
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_dac.c misc.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/stm32_adc/: stm32_adc.c
    ../HARDWARE/stm32_dac/: stm32_dac.c
    ../HARDWARE/stm32_led/: stm32_led.c
    ../HARDWARE/stm32_tim2/: stm32_tim2.c
